SUMMARY = "Test image"

IMAGE_LINGUAS = "en-us"

inherit core-image

export IMAGE_BASENAME = "very-basic-image"
